require winlink-image-base.bb

IMAGE_INSTALL:append = " packagegroup-meta-winlink"
