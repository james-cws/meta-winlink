require winlink-image-base.bb

IMAGE_INSTALL += "pat"
